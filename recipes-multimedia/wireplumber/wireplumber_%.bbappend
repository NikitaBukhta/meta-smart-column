# The recipe installs the system-wide session manager but doesn't enable it
SYSTEMD_SERVICE:${PN} = "wireplumber.service"
