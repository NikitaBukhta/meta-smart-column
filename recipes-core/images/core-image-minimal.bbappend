IMAGE_INSTALL:append = " smart-column-platform"
